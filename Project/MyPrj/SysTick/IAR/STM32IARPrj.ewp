# IAR project STM32IARPrj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\LIB\CMSIS\CM3\coreST\inc; ..\..\..\..\LIB\FireLIB\inc; ..\..\..\..\LIB\STM32F10x_StdPeriph_Driver\inc; ..; ..\..\..\..\LIB\YhbLIB\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32GPIO.hex
  ILINK.IlinkOutputFile: STM32SysTick.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group LIB/CMSIS/coreST
    ../../../../LIB/CMSIS/CM3/coreST/src/: core_cm3.c system_stm32f10x.c
  group LIB/CMSIS/STM32StartUp
    ../../../../LIB/CMSIS/CM3/stm32startup/: startup_stm32f10x_hd.s
  group LIB/FireLIB
    ../../../../LIB/FireLIB/src/: bsp_beep.c bsp_clkconfig.c bsp_exti.c bsp_iwdg.c bsp_key.c bsp_led.c bsp_mcooutput.c bsp_SysTick.c
  group LIB/STM32LIB
    ../../../../LIB/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group LIB/YhbLIB
    ../../../../LIB/YhbLIB/src/: Yhb_SysTick.c
  group User
    ../: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
