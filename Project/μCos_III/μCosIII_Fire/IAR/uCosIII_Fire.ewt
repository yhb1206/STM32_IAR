<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>LIB</name>
    <group>
      <name>CMSIS</name>
      <group>
        <name>coreST</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\LIB\CMSIS\CM3\coreST\src\core_cm3.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\LIB\CMSIS\CM3\coreST\src\system_stm32f10x.c</name>
        </file>
      </group>
      <group>
        <name>STM32StartUp</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\LIB\CMSIS\CM3\stm32startup\startup_stm32f10x_hd.s</name>
        </file>
      </group>
    </group>
    <group>
      <name>FireLIB</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\FireLIB\src\bsp_beep.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\FireLIB\src\bsp_clkconfig.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\FireLIB\src\bsp_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\FireLIB\src\bsp_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\FireLIB\src\bsp_key.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\FireLIB\src\bsp_led.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\FireLIB\src\bsp_mcooutput.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\FireLIB\src\bsp_SysTick.c</name>
      </file>
    </group>
    <group>
      <name>STM32LIB</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\STM32F10x_StdPeriph_Driver\src\misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\STM32F10x_StdPeriph_Driver\src\stm32f10x_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\STM32F10x_StdPeriph_Driver\src\stm32f10x_bkp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\STM32F10x_StdPeriph_Driver\src\stm32f10x_can.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\STM32F10x_StdPeriph_Driver\src\stm32f10x_cec.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\STM32F10x_StdPeriph_Driver\src\stm32f10x_crc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\STM32F10x_StdPeriph_Driver\src\stm32f10x_dac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\STM32F10x_StdPeriph_Driver\src\stm32f10x_dbgmcu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\STM32F10x_StdPeriph_Driver\src\stm32f10x_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\STM32F10x_StdPeriph_Driver\src\stm32f10x_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\STM32F10x_StdPeriph_Driver\src\stm32f10x_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\STM32F10x_StdPeriph_Driver\src\stm32f10x_fsmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\STM32F10x_StdPeriph_Driver\src\stm32f10x_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\STM32F10x_StdPeriph_Driver\src\stm32f10x_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\STM32F10x_StdPeriph_Driver\src\stm32f10x_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\STM32F10x_StdPeriph_Driver\src\stm32f10x_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\STM32F10x_StdPeriph_Driver\src\stm32f10x_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\STM32F10x_StdPeriph_Driver\src\stm32f10x_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\STM32F10x_StdPeriph_Driver\src\stm32f10x_sdio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\STM32F10x_StdPeriph_Driver\src\stm32f10x_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\STM32F10x_StdPeriph_Driver\src\stm32f10x_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\STM32F10x_StdPeriph_Driver\src\stm32f10x_usart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\STM32F10x_StdPeriph_Driver\src\stm32f10x_wwdg.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>User</name>
    <group>
      <name>APP</name>
      <file>
        <name>$PROJ_DIR$\..\APP\app.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\APP\app_cfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\APP\cpu_cfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\APP\lib_cfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\APP\os_app_hooks.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\APP\os_cfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\APP\os_cfg_app.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f10x_conf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f10x_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32f10x_it.h</name>
      </file>
    </group>
    <group>
      <name>BSP</name>
      <file>
        <name>$PROJ_DIR$\..\BSP\bsp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\BSP\led\bsp_led_os.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>&#x3BC;Cos_III</name>
    <group>
      <name>uC-CPU</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uC-CPU\ARM-Cortex-M3\IAR\cpu_a.asm</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uC-CPU\ARM-Cortex-M3\IAR\cpu_c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uC-CPU\cpu_core.c</name>
      </file>
    </group>
    <group>
      <name>uC-LIB</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uC-LIB\lib_ascii.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uC-LIB\lib_math.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uC-LIB\lib_mem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uC-LIB\Ports\ARM-Cortex-M3\IAR\lib_mem_a.asm</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uC-LIB\lib_str.c</name>
      </file>
    </group>
    <group>
      <name>uCOS-III</name>
      <group>
        <name>Ports</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR\os_cpu.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR\os_cpu_a.asm</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR\os_cpu_c.c</name>
        </file>
      </group>
      <group>
        <name>Source</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uCOS-III\Source\os_cfg_app.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uCOS-III\Source\os_core.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uCOS-III\Source\os_dbg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uCOS-III\Source\os_flag.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uCOS-III\Source\os_int.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uCOS-III\Source\os_mem.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uCOS-III\Source\os_msg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uCOS-III\Source\os_mutex.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uCOS-III\Source\os_pend_multi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uCOS-III\Source\os_prio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uCOS-III\Source\os_q.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uCOS-III\Source\os_sem.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uCOS-III\Source\os_stat.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uCOS-III\Source\os_task.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uCOS-III\Source\os_tick.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uCOS-III\Source\os_time.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uCOS-III\Source\os_tmr.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\LIB\&#x3BC;Cos_III\uCOS-III\Source\os_var.c</name>
        </file>
      </group>
    </group>
  </group>
</project>


