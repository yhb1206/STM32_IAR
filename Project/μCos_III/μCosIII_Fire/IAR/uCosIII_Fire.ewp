# IAR project uCosIII_Fire.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\LIB\CMSIS\CM3\coreST\inc; ..\..\..\..\LIB\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\LIB\FireLIB\inc; ..; ..\APP; ..\BSP; ..\BSP\led; ..\..\..\..\LIB\μCos_III\uC-CPU; ..\..\..\..\LIB\μCos_III\uC-CPU\ARM-Cortex-M3\IAR; ..\..\..\..\LIB\μCos_III\uC-LIB; ..\..\..\..\LIB\μCos_III\uCOS-III\Source; ..\..\..\..\LIB\μCos_III\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32GPIO.hex
  ILINK.IlinkOutputFile: uCosIII_Fire.out
  ILINK.IlinkIcfFile: ..\..\..\..\LIB\icf\μCos_III\STM32_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group LIB/CMSIS/coreST
    ../../../../LIB/CMSIS/CM3/coreST/src/: core_cm3.c system_stm32f10x.c
  group LIB/CMSIS/STM32StartUp
    ../../../../LIB/CMSIS/CM3/stm32startup/: startup_stm32f10x_hd.s
  group LIB/FireLIB
    ../../../../LIB/FireLIB/src/: bsp_beep.c bsp_clkconfig.c bsp_exti.c bsp_iwdg.c bsp_key.c bsp_led.c bsp_mcooutput.c bsp_SysTick.c
  group LIB/STM32LIB
    ../../../../LIB/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User/APP
    ../APP/: app.c app_cfg.h cpu_cfg.h lib_cfg.h os_app_hooks.c os_cfg.h os_cfg_app.h
    ../: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group User/BSP
    ../BSP/: bsp.c
    ../BSP/led/: bsp_led_os.c
  group μCos_III/uC-CPU
    ../../../../LIB/μCos_III/uC-CPU/ARM-Cortex-M3/IAR/: cpu_a.asm cpu_c.c
    ../../../../LIB/μCos_III/uC-CPU/: cpu_core.c
  group μCos_III/uC-LIB
    ../../../../LIB/μCos_III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../../../LIB/μCos_III/uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group μCos_III/uCOS-III/Ports
    ../../../../LIB/μCos_III/uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group μCos_III/uCOS-III/Source
    ../../../../LIB/μCos_III/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
